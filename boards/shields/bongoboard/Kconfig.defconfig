## boards/shields/bongoboard/Kconfig.defconfig
```kconfig
if SHIELD_BONGOBOARD

config ZMK_KEYBOARD_NAME
    default "bongoboard"

endif # SHIELD_BONGOBOARD
```
